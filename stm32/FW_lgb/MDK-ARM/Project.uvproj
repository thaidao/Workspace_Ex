# Keil uVision project Project.uvproj, settings and files
target GH12 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GH12 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,HAVE_CONFIG_H
  c include: ..\Libraries\STM32F10x_Speex_Lib;..\Libraries\STM32F10x_Speex_Lib\include;..\Libraries\STM32F10x_Speex_Lib\libspeex;..\Libraries\STM32F10x_Speex_Lib\STM32;..\Libraries\STM32F10x_Speex_Lib\STM32\include;..\Libraries\STM32F10x_Speex_Lib\STM32\libspeex;..\Libraries\STM32F10x_Speex_Lib\STM32\libspeex\arm;..\;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Utilities\STM32_EVAL;..\Utilities\STM32_EVAL\STM32100E_EVAL;..\Utilities\STM32_EVAL\Common;..\App;..\Modules;..\App\Include
  memory RVCT4: ROM 0x8020000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Configuration
    ../App/: startup_stm32f10x_hd.s
    ../App/RTX/: RTX_Conf_CM.c
  group Initialization
    ../App/: STM32_Init.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Tasks
    ../App/: main.c stm32f10x_it.c Watchdog.c PeriodicService.c voice.c
    ../Modules/: GPRS.c
  group Modules
    ../Modules/: serial.c debug.c rtc.c logger.c utils.c FWUpgrade.c adc.c trackPrint.c printer.c http.c counter.c drvKey.c driverdb.c buzzer.c SMS_Handler.c DriverProcess.c camera.c filter.c Led.c sdfifo.c tmp100.c lgb.c adminSecurity.c sys_log.c
    ../App/: loadConfig.c BoardTest.c SystemMonitor.c io_manager.c
  group FlashFS
    ../App/FlashFS/: File_Config.c Retarget.c SPI_STM32F103.c FS_CM3.lib fs_time.c
  group Speex
    ../Libraries/STM32F10x_Speex_Lib/libspeex/: window.c bits.c exc_10_32_table.c gain_table_lbr.c lpc.c lsp.c speex.c speex_callbacks.c speex_header.c buffer.c high_lsp_tables.c lsp_tables_nb.c
    ../Libraries/STM32F10x_Speex_Lib/STM32/libspeex/: modes.c nb_celp.c quant_lsp.c vq.c cb_search.c filters.c ltp.c
  group RTX
    ../App/RTX/CM/: HAL_CM3.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group GSM
    ../Modules/: sim900.c gsm.c
  group GPS
    ../Modules/: gpsModule.c sim18.c
